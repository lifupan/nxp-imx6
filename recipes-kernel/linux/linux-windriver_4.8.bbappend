require linux-windriver-nxp-imx6.inc
