require linux-yocto-nxp-imx6.inc

KBRANCH_nxp-imx6 = "standard/nxp-imx/sdk-4.9.11/nxp-imx6"
